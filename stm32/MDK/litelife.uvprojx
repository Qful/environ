# Keil uVision project litelife.uvprojx, settings and files
target envnet (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=4 wLevel=2
  c define: STM32F10X_MD
  c include: ..\TOOL;..\TASK;..\uCOS\uCOS_CORE;..\uCOS\uCOS_USER;..\uCOS\uCOS_PORT;..\uCOS\uCOS_LIBS;..\uCOS\Cortex-M3\RealView;..\Main
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../Main/: main.c bsp.c
  group TASK
    ../TASK/: Task_BH1750.c Task_DHT11.c Task_SI7021.c Task_LED.c Tasks.c Task_18B20.c
  group TOOL
    ../TOOL/: delay.c delay.h jlink_print.c I2C.c IIC.c USART.c
  group uCOS_USER
    ../uCOS/uCOS_USER/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uCOS_PORT
    ../uCOS/uCOS_PORT/: cpu_core.c cpu_core.h cpu_def.h
  group uCOS_CORE
    ../uCOS/uCOS_CORE/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uCOS_LIBS
    ../uCOS/uCOS_LIBS/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uCOS_MDK
    ../uCOS/Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c lib_mem_a.asm os_cpu.h os_cpu_a.s os_cpu_c.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
